# IAR project led_control.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM3S9B96 TexasInstruments LM3S9B96
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: TARGET_IS_TEMPEST_RC3; TNKERNEL_PORT_CORTEXM3; ewarm; DEBUG
  ICCARM.CCIncludePath2: E:\_ARM\TrafficLight\StellarisWare
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: led_control.bin
  ILINK.IlinkOutputFile: led_control.out
  ILINK.IlinkIcfFile: src\linker_script_debug.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: TARGET_IS_TEMPEST_RC3; TNKERNEL_PORT_CORTEXM3; ewarm; NDEBUG
  ICCARM.CCIncludePath2: D:\asudd\StellarisWare
  OBJCOPY.OOCOutputFile: KURS1_2.0.5_2015.01.06.bin
  group driverlib
    ../StellarisWare/driverlib/: adc.c adc.h can.c can.h comp.c comp.h cpu.c cpu.h debug.h epi.c epi.h ethernet.c ethernet.h flash.c flash.h gpio.c gpio.h hibernate.c hibernate.h i2c.c i2c.h i2s.c i2s.h interrupt.c interrupt.h mpu.c mpu.h pin_map.h pwm.c pwm.h qei.c qei.h rom.h rom_map.h ssi.c ssi.h sysctl.c sysctl.h systick.c systick.h timer.c timer.h uart.c uart.h udma.c udma.h usb.c usb.h watchdog.c watchdog.h
    ../../StellarisWare/driverlib/: Makefile
  group src
    src/: adcc.c adcc.h crc16.c crc32.c crc32.h device.c device.h linker_script_debug.icf linker_script_release.icf main.c mem_map.h pins.c pins.h pref.c pref.h spi.c spi.h startup.c stellaris.h tn_user.c tn_user.h utime.c utime.h version.c version.h vpu.c vpu.h
  group src/debug
    src/debug/: debug.c debug.h
  group src/debug/lm3s90_uart
    src/debug/lm3s90_uart/: lm3s90_uart.c lm3s90_uart.h
  group src/digi
    src/digi/: digi_utils.c digi_utils.h
  group src/dk
    src/dk/: dk.c dk.h kurs.c kurs.h structures.h takts.c takts.h
  group src/event
    src/event/: evt_fifo.c evt_fifo.h
  group src/gps
    src/gps/: gps.c gps.h
  group src/light
    src/light/: light.c light.h
  group src/lwip
    src/lwip/: api_lib.c api_msg.c asn1_dec.c asn1_enc.c autoip.c dhcp.c dns.c err.c etharp.c ethernetif.c icmp.c igmp.c inet.c inet_chksum.c init.c ip.c ip_addr.c ip_frag.c loopif.c lwiplib.c lwiplib.h lwipopts.h mem.c memp.c mib2.c mib_structs.c msg_in.c msg_out.c netbuf.c netdb.c netif.c netifapi.c pbuf.c perf.c raw.c slipif.c sockets.c stats.c stellarisif.c sys.c sys_arch.c tcp.c tcp_in.c tcp_out.c tcpip.c udp.c
  group src/lwip/arch
    src/lwip/arch/: bpstruct.h cc.h epstruct.h perf.h sys_arch.h
  group src/lwip/lwip
    src/lwip/lwip/: api.h api_msg.h arch.h autoip.h debug.h def.h dhcp.h dns.h err.h icmp.h igmp.h inet.h inet_chksum.h init.h ip.h ip_addr.h ip_frag.h mem.h memp.h memp_std.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h snmp_asn1.h snmp_msg.h snmp_structs.h sockets.h stats.h sys.h tcp.h tcpip.h udp.h
  group src/lwip/netif
    src/lwip/netif/: etharp.h loopif.h ppp_oe.h slipif.h stellarisif.h
  group src/memory
    src/memory/: ds1390.c ds1390.h firmware.c firmware.h lm3sxxx.c lm3sxxx.h memory.c memory.h sst25vfxxx.c sst25vfxxx.h
  group src/multicast
    src/multicast/: cmd_ch.c cmd_ch.h cmd_fn.c cmd_fn.h
  group src/sim900
    src/sim900/: sim900.c sim900.h sim900_protokol.c sim900_protokol.h
  group src/tnkernel
    src/tnkernel/: tn.c tn.h tn_dqueue.c tn_event.c tn_mem.c tn_mutex.c tn_port.h tn_sem.c tn_tasks.c tn_utils.c tn_utils.h
  group src/tnkernel/cm3
    src/tnkernel/cm3/: tn_port_cm3.c tn_port_cm3_iar.s
  group src/usb
    src/usb/: usb_dev_serial.c usb_dev_serial.h usb_serial_structs.c usb_serial_structs.h
  group usblib
    ../StellarisWare/usblib/: usb-ids.h usbaudio.h usbbuffer.c usbcdc.h usbdesc.c usbdfu.h usbhid.h usbkeyboardmap.c usblib.h usblibpriv.h usbmode.c usbmsc.h usbringbuf.c usbtick.c
  group usblib/device
    ../StellarisWare/usblib/device/: usbdaudio.c usbdaudio.h usbdbulk.c usbdbulk.h usbdcdc.c usbdcdc.h usbdcdesc.c usbdcomp.c usbdcomp.h usbdconfig.c usbddfu-rt.c usbddfu-rt.h usbdenum.c usbdevice.h usbdevicepriv.h usbdhandler.c usbdhid.c usbdhid.h usbdhidkeyb.c usbdhidkeyb.h usbdhidmouse.c usbdhidmouse.h usbdmsc.c usbdmsc.h
