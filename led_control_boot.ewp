# IAR project led_control_boot.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM3S9B96 TexasInstruments LM3S9B96
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: TARGET_IS_TEMPEST_RC3; TNKERNEL_PORT_CORTEXM3; ewarm; DEBUG
  ICCARM.CCIncludePath2: C:\StellarisWare
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: 5.srec
  ILINK.IlinkOutputFile: led_control_boot.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: TARGET_IS_TEMPEST_RC3; TNKERNEL_PORT_CORTEXM3; ewarm; NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: led_control_boot.bin
  ILINK.IlinkIcfFile: src\linker_script_boot.icf
  group src
    src/: boot.c crc32.c crc32.h linker_script_boot.icf mem_map.h pins.c pins.h startup_boot.c stellaris.h tn_user.c tn_user.h
  group src/debug
    src/debug/: debug.c debug.h
  group src/debug/lm3s90_uart
    src/debug/lm3s90_uart/: lm3s90_uart.c lm3s90_uart.h
  group src/memory
    src/memory/: firmware.c firmware.h lm3sxxx.c lm3sxxx.h memory.c memory.h
  group src/tnkernel
    src/tnkernel/: tn.c tn.h
  group src/tnkernel/cm3
    src/tnkernel/cm3/: tn_port_cm3_iar.s
