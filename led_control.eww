<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\led_control.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\led_control_boot.ewp</path>
  </project>
  <batchBuild/>
</workspace>


